// font5x7.c — minimal 5x7 bitmap font, just the glyphs the DSKY needs:
// digits 0-9, capitals A-Z, plus '+', '-', and space. Each glyph is 5 bytes
// (one byte per column, LSB = top pixel). Anything outside this set renders
// as a blank cell.

#include <stdint.h>

#include "font5x7.h"

// Public lookup: each entry is 5 column-bytes. Cells are 6px wide on screen
// (5 glyph columns + 1 spacing column).
const uint8_t font5x7[FONT_GLYPH_COUNT][FONT_GLYPH_BYTES] = {
    [FONT_SPACE] = {0x00, 0x00, 0x00, 0x00, 0x00},
    [FONT_PLUS]  = {0x08, 0x08, 0x3E, 0x08, 0x08},
    [FONT_MINUS] = {0x08, 0x08, 0x08, 0x08, 0x08},
    [FONT_DIGIT_0 + 0] = {0x3E, 0x51, 0x49, 0x45, 0x3E},
    [FONT_DIGIT_0 + 1] = {0x00, 0x42, 0x7F, 0x40, 0x00},
    [FONT_DIGIT_0 + 2] = {0x42, 0x61, 0x51, 0x49, 0x46},
    [FONT_DIGIT_0 + 3] = {0x21, 0x41, 0x45, 0x4B, 0x31},
    [FONT_DIGIT_0 + 4] = {0x18, 0x14, 0x12, 0x7F, 0x10},
    [FONT_DIGIT_0 + 5] = {0x27, 0x45, 0x45, 0x45, 0x39},
    [FONT_DIGIT_0 + 6] = {0x3C, 0x4A, 0x49, 0x49, 0x30},
    [FONT_DIGIT_0 + 7] = {0x01, 0x71, 0x09, 0x05, 0x03},
    [FONT_DIGIT_0 + 8] = {0x36, 0x49, 0x49, 0x49, 0x36},
    [FONT_DIGIT_0 + 9] = {0x06, 0x49, 0x49, 0x29, 0x1E},
    [FONT_LETTER_A + ('A' - 'A')] = {0x7E, 0x11, 0x11, 0x11, 0x7E},
    [FONT_LETTER_A + ('B' - 'A')] = {0x7F, 0x49, 0x49, 0x49, 0x36},
    [FONT_LETTER_A + ('C' - 'A')] = {0x3E, 0x41, 0x41, 0x41, 0x22},
    [FONT_LETTER_A + ('D' - 'A')] = {0x7F, 0x41, 0x41, 0x22, 0x1C},
    [FONT_LETTER_A + ('E' - 'A')] = {0x7F, 0x49, 0x49, 0x49, 0x41},
    [FONT_LETTER_A + ('F' - 'A')] = {0x7F, 0x09, 0x09, 0x09, 0x01},
    [FONT_LETTER_A + ('G' - 'A')] = {0x3E, 0x41, 0x49, 0x49, 0x7A},
    [FONT_LETTER_A + ('H' - 'A')] = {0x7F, 0x08, 0x08, 0x08, 0x7F},
    [FONT_LETTER_A + ('I' - 'A')] = {0x00, 0x41, 0x7F, 0x41, 0x00},
    [FONT_LETTER_A + ('J' - 'A')] = {0x20, 0x40, 0x41, 0x3F, 0x01},
    [FONT_LETTER_A + ('K' - 'A')] = {0x7F, 0x08, 0x14, 0x22, 0x41},
    [FONT_LETTER_A + ('L' - 'A')] = {0x7F, 0x40, 0x40, 0x40, 0x40},
    [FONT_LETTER_A + ('M' - 'A')] = {0x7F, 0x02, 0x0C, 0x02, 0x7F},
    [FONT_LETTER_A + ('N' - 'A')] = {0x7F, 0x04, 0x08, 0x10, 0x7F},
    [FONT_LETTER_A + ('O' - 'A')] = {0x3E, 0x41, 0x41, 0x41, 0x3E},
    [FONT_LETTER_A + ('P' - 'A')] = {0x7F, 0x09, 0x09, 0x09, 0x06},
    [FONT_LETTER_A + ('Q' - 'A')] = {0x3E, 0x41, 0x51, 0x21, 0x5E},
    [FONT_LETTER_A + ('R' - 'A')] = {0x7F, 0x09, 0x19, 0x29, 0x46},
    [FONT_LETTER_A + ('S' - 'A')] = {0x46, 0x49, 0x49, 0x49, 0x31},
    [FONT_LETTER_A + ('T' - 'A')] = {0x01, 0x01, 0x7F, 0x01, 0x01},
    [FONT_LETTER_A + ('U' - 'A')] = {0x3F, 0x40, 0x40, 0x40, 0x3F},
    [FONT_LETTER_A + ('V' - 'A')] = {0x1F, 0x20, 0x40, 0x20, 0x1F},
    [FONT_LETTER_A + ('W' - 'A')] = {0x7F, 0x20, 0x18, 0x20, 0x7F},
    [FONT_LETTER_A + ('X' - 'A')] = {0x63, 0x14, 0x08, 0x14, 0x63},
    [FONT_LETTER_A + ('Y' - 'A')] = {0x07, 0x08, 0x70, 0x08, 0x07},
    [FONT_LETTER_A + ('Z' - 'A')] = {0x61, 0x51, 0x49, 0x45, 0x43},
};

int font_index(char c)
{
    if (c == ' ') return FONT_SPACE;
    if (c == '+') return FONT_PLUS;
    if (c == '-') return FONT_MINUS;
    if (c >= '0' && c <= '9') return FONT_DIGIT_0 + (c - '0');
    if (c >= 'A' && c <= 'Z') return FONT_LETTER_A + (c - 'A');
    if (c >= 'a' && c <= 'z') return FONT_LETTER_A + (c - 'a');
    return FONT_SPACE;
}
